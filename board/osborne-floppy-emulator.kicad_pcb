# Repository archiecarrot123/osborne-floppy-emulator

## KiCad design board/osborne-floppy-emulator.kicad_pcb

Parts:
J2: USB_A; USB_A_TE_292303-7_Horizontal; Mouser part no. 737-USB-A-S-RA-SMT
J3: SWD Connector; PinSocket_1x04_P2.54mm_Vertical; Mouser part no. 737-RS1-04-G

Connections:
+3V3: J3.1; also elsewhere on the board
+5V: J2.1 (VBUS); also elsewhere on the board
/Processor/Debug clock: J3.3; also elsewhere on the board
/Processor/Debug data: J3.4; also elsewhere on the board
/Processor/Port D+: J2.3 (D+); also elsewhere on the board
/Processor/Port D-: J2.2 (D-); also elsewhere on the board

Parts:
J1: Connector Out; PinHeader_2x17_P2.54mm_Vertical_SMD; Mouser part no. 855-M20-7812045
J4: Connector In; PinSocket_2x17_P2.54mm_Vertical_SMD; Mouser part no. 855-M20-7872042
Q5, Q6: BC847C; SOT-23_Handsoldering; Mouser part no. 771-BC847C-T/R

Connections:
+5V: J1.21, J1.23, J1.25, J4.21, J4.23, J4.25; also elsewhere on the board
/Connector/DS 1 Enable: Q5.2 (B); also elsewhere on the board
/Connector/DS 2 Enable: Q6.2 (B); also elsewhere on the board
/Connector/Read Data: J1.30, J4.30; also elsewhere on the board
/Connector/~4MHz: J1.16, J4.16; also elsewhere on the board
/Connector/~DS 1: J4.10, Q5.3 (E); also elsewhere on the board
/Connector/~DS 2: J4.12, Q6.3 (E); also elsewhere on the board
/Connector/~Direction: J1.18, J4.18; also elsewhere on the board
/Connector/~Early: J1.6, J4.6; also elsewhere on the board
/Connector/~Index: J1.8, J4.8; also elsewhere on the board
/Connector/~Late: J1.34, J4.34; also elsewhere on the board
/Connector/~Side Select: J1.32, J4.32; also elsewhere on the board
/Connector/~Step: J1.20, J4.20; also elsewhere on the board
/Connector/~TG43: J1.4, J4.4; also elsewhere on the board
/Connector/~Track 00: J1.26, J4.26; also elsewhere on the board
/Connector/~Write Data: J1.22, J4.22; also elsewhere on the board
/Connector/~Write Gate: J1.24, J4.24; also elsewhere on the board
/Connector/~Write Protect: J1.28, J4.28; also elsewhere on the board
unnamed: J1.10, Q5.1 (C)
unnamed: J1.12, Q6.1 (C)

Notes on the sheet:
TG43: Low if track number greater than 43 (from FDC???) Early: Low if write data should be shifted earlier Index: Pull this low when the index hole goes past DS 1: Low if drive 1 selected DS 2: Low if drive 2 selected 4MHz: This is the (inverted) CPU clock from the mainboard Direction: High to move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
The technical manual tells lies! Read the schematics
I think that this connector is after the FDC, not before it, so we will actually have to simulate the working of a FDD
All inputs are buffered and pulled up to 5V on the mainboard All outputs are inverted on the mainboard The inverters are open-collector so we'll need pull-up resistors if we want to work without the FDDs
Our Osborne 1 has board revision F and part revision J, and a "President DD" daughterboard between the 8877 and its socket

Parts:
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: FDLL4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Mouser part no. 512-FDLL4148
Q4, Q7, Q8, Q9: BC847C; SOT-23_Handsoldering; Mouser part no. 771-BC847C-T/R
R14, R16, R17, R18, R19: 27k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Mouser part no. 603-RE0805FRE0727KL

Connections:
+3V3: R19.1; also elsewhere on the board
/Connector/Read Data: Q9.1 (C); also elsewhere on the board
/Connector/~4MHz: D4.1 (K); also elsewhere on the board
/Connector/~DS 1: D3.1 (K); also elsewhere on the board
/Connector/~DS 2: D9.1 (K); also elsewhere on the board
/Connector/~Direction: D10.1 (K); also elsewhere on the board
/Connector/~Early: D8.1 (K); also elsewhere on the board
/Connector/~Index: Q4.1 (C); also elsewhere on the board
/Connector/~Late: D7.1 (K); also elsewhere on the board
/Connector/~Side Select: D12.1 (K); also elsewhere on the board
/Connector/~Step: D5.1 (K); also elsewhere on the board
/Connector/~TG43: D2.1 (K); also elsewhere on the board
/Connector/~Track 00: Q7.1 (C); also elsewhere on the board
/Connector/~Write Data: D11.1 (K); also elsewhere on the board
/Connector/~Write Gate: D6.1 (K); also elsewhere on the board
/Connector/~Write Protect: Q8.1 (C); also elsewhere on the board
/Level Shifter/Index CMOS: R14.1; also elsewhere on the board
/Level Shifter/Track 00 CMOS: R16.1; also elsewhere on the board
/Level Shifter/Write Protect CMOS: R17.1; also elsewhere on the board
/Level Shifter/~4MHz CMOS: D4.2 (A), R19.2; also elsewhere on the board
/Level Shifter/~DS 1 CMOS: D3.2 (A); also elsewhere on the board
/Level Shifter/~DS 2 CMOS: D9.2 (A); also elsewhere on the board
/Level Shifter/~Direction CMOS: D10.2 (A); also elsewhere on the board
/Level Shifter/~Early CMOS: D8.2 (A); also elsewhere on the board
/Level Shifter/~Late CMOS: D7.2 (A); also elsewhere on the board
/Level Shifter/~Read Data CMOS: R18.1; also elsewhere on the board
/Level Shifter/~Side Select CMOS: D12.2 (A); also elsewhere on the board
/Level Shifter/~Step CMOS: D5.2 (A); also elsewhere on the board
/Level Shifter/~TG43 CMOS: D2.2 (A); also elsewhere on the board
/Level Shifter/~Write Data CMOS: D11.2 (A); also elsewhere on the board
/Level Shifter/~Write Gate CMOS: D6.2 (A); also elsewhere on the board
unnamed: Q4.2 (B), R14.2
unnamed: Q7.2 (B), R16.2
unnamed: Q8.2 (B), R17.2
unnamed: Q9.2 (B), R18.2

Notes on the sheet:
Internal pull-ups should be used, and the diodes should be placed near the RP2040
These outputs of the emulator are pulled up on the mainboard, so there is no need for a pull-up resistor.

Parts:
C1: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser part no. 710-885012206095
Cin1: 100u; CP_Radial_D6.3mm_P2.50mm; Mouser part no. 710-860080473006
Cout1, Cout2: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Mouser part no. 187-CL21A106KOQNNNE
D1: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal; Mouser part no. 833-1N5819-TP
L1: 1m; L_CommonModeChoke_Murata_5000_Series; Mouser part no. 580-50105C
L3: 10u; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder; Mouser part no. 963-LBR2518T100K
Q1: T2N7002BK; SOT-23_Handsoldering; Mouser part no. 757-T2N7002BKLM

Connections:
+3V3: Cout2.1; also elsewhere on the board
+5V: Cin1.1, L1.1; also elsewhere on the board
/SEPIC/FEEDBACK: Cout1.1, D1.1 (K); also elsewhere on the board
/SEPIC/GATE: Q1.1 (C); also elsewhere on the board

Parts:
C5, C8, C9, C10, C11, C12, C13: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser part no. 710-885012206095
C6, C7: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Mouser part no. 187-CL21B105KAFNFNE
R7, R8: 27.4; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser part no. 71-CRCW060327R4FKEAC
R15: 27k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-27K
TP1: RUN; TestPoint_Pad_D2.0mm
TP2: SWC; TestPoint_Pad_D2.0mm
TP3: SWD; TestPoint_Pad_D2.0mm
TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17: TestPoint; TestPoint_Pad_D1.0mm
U1: W25Q16JVSSIM; SOIC-8_5.23x5.23mm_P1.27mm; Mouser part no. 454-W25Q16JVSSIM
U2: RP2040; QFN-56_EP_7x7_Pitch0.4mm_Extralong; Mouser part no. 358-SC091413

Connections:
+3V3: C5.2, C7.1, C8.2, C9.1, C10.2, C11.1, C12.1, R15.1, U1.8 (VCC), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD); also elsewhere on the board
/Connector/DS 1 Enable: U2.6 (GPIO4); also elsewhere on the board
/Connector/DS 2 Enable: U2.8 (GPIO6); also elsewhere on the board
/Level Shifter/Index CMOS: U2.4 (GPIO2); also elsewhere on the board
/Level Shifter/Track 00 CMOS: U2.14 (GPIO11); also elsewhere on the board
/Level Shifter/Write Protect CMOS: U2.15 (GPIO12); also elsewhere on the board
/Level Shifter/~4MHz CMOS: U2.20 (XIN); also elsewhere on the board
/Level Shifter/~DS 1 CMOS: U2.5 (GPIO3); also elsewhere on the board
/Level Shifter/~DS 2 CMOS: U2.7 (GPIO5); also elsewhere on the board
/Level Shifter/~Direction CMOS: U2.9 (GPIO7); also elsewhere on the board
/Level Shifter/~Early CMOS: U2.3 (GPIO1); also elsewhere on the board
/Level Shifter/~Late CMOS: U2.18 (GPIO15); also elsewhere on the board
/Level Shifter/~Read Data CMOS: U2.16 (GPIO13); also elsewhere on the board
/Level Shifter/~Side Select CMOS: U2.17 (GPIO14); also elsewhere on the board
/Level Shifter/~Step CMOS: U2.11 (GPIO8); also elsewhere on the board
/Level Shifter/~TG43 CMOS: U2.2 (GPIO0); also elsewhere on the board
/Level Shifter/~Write Data CMOS: U2.12 (GPIO9); also elsewhere on the board
/Level Shifter/~Write Gate CMOS: U2.13 (GPIO10); also elsewhere on the board
/Processor/Chip D+: R7.2, U2.47 (USB_DP)
/Processor/Chip D-: R8.1, U2.46 (USB_DM)
/Processor/Debug clock: TP2.1, U2.24 (SWCLK); also elsewhere on the board
/Processor/Debug data: TP3.1, U2.25 (SWD); also elsewhere on the board
/Processor/Port D+: R7.1; also elsewhere on the board
/Processor/Port D-: R8.2; also elsewhere on the board
unnamed: U1.6 (CLK), U2.52 (QSPI_SCLK)
unnamed: U1.5 (DI(IO0)), U2.53 (QSPI_SD0)
unnamed: U1.2 (DO(IO1)), U2.55 (QSPI_SD1)
unnamed: U1.3 (IO2), U2.54 (QSPI_SD2)
unnamed: U1.7 (IO3), U2.51 (QSPI_SD3)
unnamed: U1.1 (~CS), U2.56 (QSPI_SS)
unnamed: TP8.1, U2.27 (GPIO16)
unnamed: TP9.1, U2.28 (GPIO17)
unnamed: TP10.1, U2.29 (GPIO18)
unnamed: TP11.1, U2.30 (GPIO19)
unnamed: TP12.1, U2.31 (GPIO20)
unnamed: TP13.1, U2.32 (GPIO21)
unnamed: TP14.1, U2.34 (GPIO22)
unnamed: TP15.1, U2.35 (GPIO23)
unnamed: TP16.1, U2.36 (GPIO24)
unnamed: TP17.1, U2.37 (GPIO25)
unnamed: TP6.1, U2.38 (GPIO26_ADC0)
unnamed: TP7.1, U2.39 (GPIO27_ADC1)
unnamed: TP5.1, U2.40 (GPIO28_ADC2)
unnamed: TP4.1, U2.41 (GPIO29_ADC3)
unnamed: R15.2, TP1.1, U2.26 (RUN)
unnamed: C6.2, C13.2, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)

Parts:
C1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Mouser part no. 187-CL21A106KOQNNNE
C3: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Mouser part no. 80-C0805C102J5G
C4: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser part no. 710-885012206095
Q1: BC557; TO-92_Inline; Mouser part no. 637-BC557CBK
Q2: BC547; TO-92_Inline; Mouser part no. 637-BC547CBK
R1: 0.1; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-0R1
R2, R3, R5, R12: 27k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-27K
R4: 3.6k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; Mouser part no. 603-MFR-12FTF52-3K6
R6: 7.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-7K5
R9: 56; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-56R
R10: 12k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal; Mouser part no. 603-MFR-12FTF52-12K
R11: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; Mouser part no. 603-CFR-25JT-52-1M
R13: 27k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Mouser part no. 603-RE0805FRE0727KL
U3: TL494; TSSOP-16_4.4x5mm_P0.65mm; Mouser part no. 595-TL494CPWR

Connections:
/SEPIC/FEEDBACK: R5.2; also elsewhere on the board
/SEPIC/GATE: Q1.1 (C), Q2.1 (C); also elsewhere on the board
unnamed: Q2.2 (B), R3.2, U3.11 (C2)
unnamed: R4.2, R6.1, R12.1, R13.1
unnamed: R5.1, U3.1 (1IN+)
unnamed: C4.1, R11.2, R12.2, U3.2 (1IN-)
unnamed: R9.1, R13.2, U3.15 (2IN-)
unnamed: R2.1, U3.8 (C1)
unnamed: C3.1, U3.5 (CT)
unnamed: C4.2, R11.1, U3.3 (FB)
unnamed: R4.1, U3.14 (REF)
unnamed: R10.1, U3.6 (RT)

Notes on the sheet:
In the typical application they use the second error amplifier to shut off the transistor if the current goes above about 1.4 A
This voltage divider (R12 and R13) means that the inverting input of the 2nd error amplifier will be pulled below ground if more than about 100 mA are drawn from the power supply
this is a trick i learned from CMOS note that the bases must NOT be connected or else they will short their emitters
The datasheet calls pin 3 the comparator input, and it decouples/filters it weirdly - it's coupled to the inverting input of the first comparator to reduce the time-derivative of the comparator input's voltage This will be very important for the SEPIC as reducing the duty cycle will cause a tempora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

Board: 2 copper layers, 61.6 x 53.7 mm, 82 parts (25 on the bottom side), 86 nets.

Other parts of the board:
C2: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
L2: 10u; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
Q3: T2N7002BK; SOT-23_Handsoldering

Their connections:
+3V3: L2.2; also elsewhere on the board
/SEPIC/FEEDBACK: L2.1; also elsewhere on the board
/SEPIC/GATE: Q3.1 (G); also elsewhere on the board

## Code that names these connections

File src/main.c (part):

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  // pull up inputs (skipping unused ones)
  gpio_pull_up(3);  // DS 1
  gpio_pull_up(5);  // DS 2
  gpio_pull_up(7);  // direction
  gpio_pull_up(8);  // step
  gpio_pull_up(9);  // write data
  gpio_pull_up(10); // write gate
  gpio_pull_up(26); // option 1
  gpio_pull_up(28); // option 2
  gpio_pull_up(29); // option 3
  // set functions on outputs
  gpio_init(2);  // index
  gpio_init(4);  // DS 1 enable
  gpio_init(6);  // DS 2 enable
  gpio_init(11); // track 0
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
## Commit log

2024-05-25 Add the Pico SDK for programming the RP2040
2024-05-25 changed part numbers for connectors
2024-05-25 change resistor part numbers to right sized ones
2024-05-25 fixed issue with OCP comparator polarity
2024-05-26 change pin headers to (more expensive) SMT ones
2024-05-26 change to cute little (cheaper) SMD diodes
2024-05-26 change most NPNs to SMD ones
2024-05-26 fix part number
2024-05-27 change some resistors to SMD
2024-05-27 fix clock signal level shifting
2024-05-27 changed regulator IC to TSSOP version
2024-05-28 Change a whole bunch of stuff for v2
2024-05-28 move board files into their own folder
2024-05-28 add fp-info-cache to .gitignore
2024-05-28 add footprints
2024-05-28 move board stuff into board folder
2024-05-29 add documentation
2024-05-29 add TPs for the extra pins to the board
2024-05-29 connect power
2024-05-29 fix footprint libraries
2024-05-29 refresh footprints
2024-05-29 fix silkscreen
2024-05-29 fix board borders and modify ground plane
2024-05-29 ignore .kicad_prl files
2024-05-29 move more of the +3V3 line to the front
2024-05-29 move silkscreen text
2024-05-30 shrink board slightly
2024-05-31 update documentation
2024-05-31 add power pin to debug connector
2024-05-31 move sym-lib-table to correct place
2024-05-31 add build to .gitignore
2024-06-01 add test program
2024-06-01 make pads on rp2040 footprint extra long
2024-06-02 fix part number for debug jumper
2024-06-02 fix connector in part number (so expensive ):
2024-06-02 fix BOM, add column for mfr. part number
2024-06-02 change 2x17 connector part numbers to ones available at LCSC
2024-06-02 exclude new TPs from BOM
2024-06-02 continued to update the docs
2024-06-03 fix BOM, add more LCSC part numbers
2024-06-15 version 2 breaks each pin out individually
2024-06-17 add PIO programs for being read and written
2024-06-18 fix readMFM timing
2024-06-18 fix timing (again)
2024-06-19 fix R18's silkscreen label missing
2024-06-20 fix R10 silkscreen label
2024-06-21 fix test.c
2024-06-26 add file for board docs
2024-06-28 turns out the pio hardware can generate irqs for the fifos
2024-07-08 add weird smaller readMFM program
2024-07-08 change readFM so clock is before data
2024-07-26 add first testing version of software
2024-07-28 auto-detect XOSC and switch to it if present
2024-07-30 Add first version of report
2024-07-30 Add some more information about the formats
2024-07-30 Improve the PIO section
2024-07-30 Complete section about gaps
2024-07-30 add some information about the preamble and the index pulse
2024-07-30 Fill out USB section and change quip about preamble
2024-07-30 Fix formatting
2024-07-31 Add renders of PCBs and change authors
2024-07-31 A whole bunch of stuff around track loading
2024-07-31 add introduction to report
2024-07-31 Formatting
2024-07-31 Remove unused latex package
2024-07-31 update introductions
2024-07-31 fix null pointer dereference
2024-07-31 change some stuff about address marks
2024-07-31 change " - " to "---"
2024-07-31 capitalise Linux
2024-07-31 Fix accent
2024-07-31 Add part of shorter report
2024-07-31 add abstract
2024-07-31 final? version
2024-07-31 wrap readpointertime
2024-07-31 fix embarassing bug in disk.c
2024-08-01 load to ram to fix speed issues
2024-08-01 reduce number of multiplications and additions, and add more checks
2024-08-02 use hardware structs everywhere
2024-08-06 added openocd configuration for raspberry pi
2024-08-06 Add openocd docs
2024-08-07 remove old auto-generated file
2024-08-07 fix timing issues
2024-08-09 fix timing errors found when using MFM
2024-08-09 fix corner case with rawread timers
2024-08-09 add test for bad pio program
2024-08-09 update docs for compiling
2024-08-09 fix merging blocks and a typo in alloc
2024-08-22 remove some stuff from when i was debugging
2024-08-22 fix track logic
2024-08-22 improve memory management logic
2024-08-23 tinyusb test can print
2024-08-23 fix minor syntax error in docs
2024-08-23 Remove empty readme
2024-08-23 fix tinyusb_test not printing last letter
2024-08-23 added source
2024-08-23 ff.h compiles but idk how to do msc stuff
2024-08-24 remove fatfs-cmake and use pico-sdk's tinyusb's fatfs instead
2024-08-27 better printf thingy and tried to implement usb thingy in tinyusb_test.c (and by implementing i mean copying most of tinyusb/examples/msc_file_explorer
2024-08-27 added inherited mit license to tinyusb_test.c
2024-08-27 a whole bunch of work in an attempt to make a barely functional thing
2024-08-27 Change CRC algorithm
2024-08-27 fix weird pio issue and add fiddle with some macros
2024-08-28 work on the sector data logic a bit
2024-08-28 non-functional msc implementation, due to the functions not being called back from tinyusb
2024-08-29 fix CRCs and improve sector loading
2024-08-29 remove clangd cache files
2024-08-31 last unworking tinyusb_test setup
2024-08-31 working? pio usb setup
2024-09-02 change status logic, MFM timing, and add ability to select disks
2024-09-03 it reacts to usb plugging in
2025-06-21 Clock debug on GPIO 21
2025-06-22 plugging in usb crashes rp2040
